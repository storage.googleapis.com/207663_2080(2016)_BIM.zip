Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-08T12:12:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 08 12:12:34 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{4D9106BD-FB35-4B9E-9F04-672BEE4E8F57}\ifc * Database version: 5507 * Database creation date: Fri Jun 08 12:12:32 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 08 12:12:32 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 08 12:12:32 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: 2080 Body for bath and shower faucet, G1/2, 2080(2016):2080 Body for bath and shower faucet, G1/2:351081
In: Level 0
Type - PredefinedType: FAUCET
Pset_ManufacturerTypeInformation - ModelReference: 2080; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2080 Body for bath and shower faucet, G1/2
